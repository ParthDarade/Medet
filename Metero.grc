options:
  parameters:
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency_0
  id: variable_qtgui_entry
  parameters:
    label: frequency
    type: real
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    label: Thresh
    start: '-10'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: thresh2
  id: variable_qtgui_range
  parameters:
    label: Low
    start: '-100'
    step: '1'
    stop: '0'
    value: '-0.1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: '-thresh2'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_grbackground_0
  id: qtgui_grbackground
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '32'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: '100'
    clock_source0: gpsdo
    freq0: '145000000'
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_burst_tagger_0, '0', analog_wfm_rcv_0, '0']
- [blocks_burst_tagger_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_threshold_ff_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_burst_tagger_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
